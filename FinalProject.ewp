# IAR project FinalProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCIncludePath2: ; ..; ..\..\..; $C:\STELLARISWARE\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: FinalProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bool.c bool.h computeTask.c computeTask.h dataPtrs.c dataPtrs.h dataStructs.c displayTask.c displayTask.h Flags.h keypadTask.c keypadTask.h main.c measureTask.c measureTask.h serialComTask.c serialComTask.h statusTask.c statusTask.h systemTimeBase.c systemTimeBase.h warningAlarm.c warningAlarm.h
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../driverlib/: pwm.h
    ../drivers/: rit128x96x4.c rit128x96x4.h
    ../hello/: startup_ewarm.c
