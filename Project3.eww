<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FinalProject.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\pwmgen\pwmgen.ewp</path>
  </project>
  <batchBuild/>
</workspace>


